# Repository crazbot/HP45-standalone-controller-V4.02

## KiCad design HP45 Standalone V4.02.kicad_pcb

Board: 2 copper layers, 44.0 x 100.0 mm, 89 parts (1 on the bottom side), 106 nets.

Parts:
C1, C9, C11: 1uF; C_0603
C2, C3, C6, C13, C14, C15, C17, C18, C19: 0.1uF; C_0603
C4, C5: 10uF; CP_Elec_4x5.8
C8: 0.1nF; C_0603
C10, C12: 100uF; CP_Elec_8x10
C16: 1uF; CP_Elec_4x5.8
Con1: HP45_connector; HP45_SMD_connector
D1, D3, D4, D5, D6: LED; LED_0603
D2, D7: D_Schottky; D_SOD-323HE
F1: Polyfuse IHold=4A; Universal_PTC
F2, F3: Polyfuse IHold=1A; R_1812
Fd1, Fd2: Fiducial; Fiducial_1mm_Dia_2mm_Outer
IC1: ADP2301; TSOP-6_1.65x3.05mm_Pitch0.95mm
IC2: 74HC123; TSSOP-16_4.4x5mm_Pitch0.65mm
IC3, IC4: TLC59213; TSSOP-20_4.4x6.5mm_Pitch0.65mm
IC5, IC6, IC9: HEF4017; SSOP-16_4.4x5.2mm_Pitch0.65mm
IC7: HCF4081; TSSOP-14_4.4x5mm_Pitch0.65mm
IC8: LM311; SOIC-8_3.9x4.9mm_Pitch1.27mm
J1: Screw_Terminal_1x03; 3.5mm_screw_terminal
J2, J4: CONN_01X03; JST_XH_B03B-XH-A_03x2.50mm_Straight
J3: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
J5: CONN_01X05; JST_XH_B05B-XH-A_05x2.50mm_Straight
J6: CONN_01X04; JST_XH_B04B-XH-A_04x2.50mm_Straight
J8: BARREL_JACK
JP1: Jumper; NC_Jumper
L1: 4.7uH; Inductor_Taiyo-Yuden_NR-50xx_HandSoldering
M1, M2, M3, M4: Mounting_hole; MountingHole_3.2mm_M3_Pad_Via
Q1, Q2: Q_NMOS_GSD; SOT-23
Q3: Q_NMOS_SGD; SO-8_PowerPAK
R1, R2, R3, R5, R8, R10, R11, R12, R17, R25, R26, R31: 2.2k; R_0603
R4, R16, R19, R22, R24, R28: 10k; R_0603
R6, R7, R9, R14, R15, R18, R21, R27: 1.2k; R_0603
R13, R20: 30; R_0805
R23, R29, R30: 330; R_0603
U1: Universal_regulator
uC1: Teensy_3.5_custom; Teensy_3.5_edges

Connections:
+3V3: C2.1, IC2.16, Q1.1, Q2.1, R3.1, R5.1, R11.2, R17.2, R24.1, R29.2, R30.2, uC1.67
+5V: D2.1, D4.2, J5.5, J6.1, uC1.69
+12V: C5.1, C6.1, C13.1, C14.1, C15.1, C17.1, C18.1, D3.2, F3.1, IC1.4, IC1.5, IC5.16, IC6.16, IC7.14, IC8.8, IC9.16, J3.1, R10.2, R12.2, R19.1, R22.1, U1.2
/ADR_TEST: R27.2, R28.1, uC1.49
/ARST: IC5.15, IC6.15, IC9.15, Q2.3, R12.1
/C10X: Con1.28, R29.1, uC1.60
/CACLK: Q1.2, R11.1, uC1.7
/CARST: Q2.2, R17.1, uC1.62
/CH-A: J6.3, uC1.46
/CH-B: J6.2, uC1.47
/CTSR: Con1.27, R30.1, uC1.59
/DUMMY1: IC3.9, uC1.21
/DUMMY2: IC4.2, uC1.22
/EXT1: J5.2, uC1.16
/EXT2: J5.3, uC1.17
/EXT3: J5.4, uC1.18
/HA00: Con1.25, IC5.6
/HA01: Con1.29, IC5.4
/HA02: Con1.23, IC5.7
/HA03: Con1.31, IC5.5
/HA04: Con1.17, IC6.10
/HA05: Con1.37, IC5.1
/HA06: Con1.15, IC6.9
/HA07: Con1.39, IC5.2
/HA08: Con1.1, IC6.1
/HA09: Con1.45, IC5.9
/HA10: Con1.6, IC9.10
/HA11: Con1.47, IC5.10
/HA12: Con1.8, IC9.4
/HA13: Con1.52, IC6.2
/HA14: Con1.14, IC9.5
/HA15: Con1.38, IC6.4
/HA16: Con1.16, IC9.2
/HA17: Con1.36, IC6.5
/HA18: Con1.22, IC9.7
/HA19: Con1.30, IC6.6
/HA20: Con1.24, IC9.1
/HA21: Con1.26, IC6.7
/HDUMMY1: IC3.12, R13.1
/HDUMMY2: IC4.19, R20.1
/HENA: D5.2, R23.2, uC1.5
/HGND: C16.1, Con1.2, Con1.5, Con1.9, Con1.10, Con1.11, Con1.18, Con1.19, Con1.34, Con1.35, Con1.42, Con1.43, Con1.44, Con1.48, Con1.51, IC8.3, Q3.3, R13.2, R14.1, R20.2
/HP00: Con1.21, IC3.16
/HP01: Con1.20, IC4.14
/HP02: Con1.13, IC3.17
/HP03: Con1.12, IC4.13
/HP04: Con1.7, IC3.18
/HP05: Con1.4, IC4.12
/HP06: Con1.3, IC3.19
/HP07: Con1.50, IC4.18
/HP08: Con1.49, IC3.13
/HP09: Con1.46, IC4.17
/HP10: Con1.41, IC3.14
/HP11: Con1.40, IC4.16
/HP12: Con1.33, IC3.15
/HP13: Con1.32, IC4.15
/NCHECK: IC8.7, R24.2, uC1.6
/P00: IC3.5, uC1.11
/P01: IC4.7, uC1.65
/P02: IC3.4, uC1.10
/P03: IC4.8, uC1.66
/P04: IC3.3, uC1.9
/P05: IC4.9, uC1.4
/P06: IC3.2, uC1.8
/P07: IC4.3, uC1.56
/P08: IC3.8, uC1.14
/P09: IC4.4, uC1.57
/P10: IC3.7, uC1.13
/P11: IC4.5, uC1.58
/P12: IC3.6, uC1.12
/P13: IC4.6, uC1.63
/PCLK: IC2.1, IC3.10, IC4.10, uC1.64
/PCLR: IC2.4, IC3.1, IC4.1
/RX: J2.2, uC1.2
/SCL: J4.3, uC1.50
/SDA: J4.2, uC1.51
/STATUS: D6.2, uC1.61
/TEST-12V: R18.1, R19.2, uC1.23
/TEST-VHD: R15.1, R16.2, uC1.24
/TX: J2.3, uC1.3
AGND: C13.2, C14.2, C15.2, C17.2, C19.1, IC5.8, IC6.8, IC7.7, IC7.8, IC7.9, IC7.12, IC7.13, IC9.8, R14.2, R26.1
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C16.2, C18.2, C19.2, D7.2, IC1.2, IC2.8, IC2.14, IC3.11, IC4.11, IC8.1, IC8.4, J1.1, J2.1, J3.2, J4.1, J5.1, J6.4, J8.2, J8.3, Q3.1, R1.2, R2.2, R6.2, R7.2, R8.1, R9.2, R15.2, R18.2, R21.2, R25.1, R26.2, R27.1, U1.1, U1.4, uC1.1
unnamed: C1.1, C4.1, F2.2, J3.3, L1.1, R4.2, U1.3
unnamed: C3.1, D7.1, IC1.6, L1.2
unnamed: C3.2, IC1.1
unnamed: C8.1, IC2.15, R3.2
unnamed: D1.1, R1.1
unnamed: D2.2, F2.1
unnamed: D3.1, R2.1
unnamed: D4.1, R6.1
unnamed: D5.1, R7.1
unnamed: D6.1, R9.1
unnamed: F1.2, J1.3, JP1.1
unnamed: F3.2, J1.2, J8.1, JP1.2
unnamed: IC1.3, R8.2, R31.1
unnamed: IC2.2, IC2.3, R5.2
unnamed: IC5.11, IC5.13, IC7.2
unnamed: IC5.14, IC7.1, IC7.5, Q1.3, R10.1
unnamed: IC6.11, IC6.13, IC7.6
unnamed: IC6.14, IC7.3
unnamed: IC7.4, IC9.14
unnamed: IC8.2, R21.1, R22.2
unnamed: IC9.6, IC9.13, R28.2
unnamed: Q3.2, R23.1, R25.2
unnamed: R4.1, R31.2
VHead: C9.1, C10.1, C11.1, C12.1, D1.2, F1.1, IC3.20, IC4.20, R16.1

## Commit log

2023-05-10 Power input
2023-05-11 complete schema
